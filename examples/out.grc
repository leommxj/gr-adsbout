<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1090e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>adsbout_adsb_Concentrator</key>
<param><key>id</key><value>adsbout_adsb_Concentrator_0</value></param>
<param><key>gap</key><value>995640</value></param>
<param><key>ninputs</key><value>4</value></param>
</block>
<block>
<key>adsbout_adsb_ident_source</key>
<param><key>id</key><value>adsbout_adsb_ident_source_0</value></param>
<param><key>callsign</key><value>AB123</value></param>
<param><key>ec</key><value>3</value></param>
<param><key>icao</key><value>0x666888</value></param>
</block>
<block>
<key>adsbout_adsb_ident_source</key>
<param><key>id</key><value>adsbout_adsb_ident_source_1</value></param>
<param><key>callsign</key><value>CC1234</value></param>
<param><key>ec</key><value>3</value></param>
<param><key>icao</key><value>0x666777</value></param>
</block>
<block>
<key>adsbout_adsb_position_source</key>
<param><key>id</key><value>adsbout_adsb_position_source_0</value></param>
<param><key>altitude</key><value>9876.4</value></param>
<param><key>capability</key><value>5</value></param>
<param><key>icao</key><value>0x666888</value></param>
<param><key>intermessagegap</key><value>99564</value></param>
<param><key>latitude</key><value>40.0773267203</value></param>
<param><key>longitude</key><value>116.6003801203</value></param>
<param><key>nicsupplementb</key><value>0</value></param>
<param><key>surface</key><value>False</value></param>
<param><key>surveillancestatus</key><value>0</value></param>
<param><key>time</key><value>0</value></param>
<param><key>typecode</key><value>11</value></param>
</block>
<block>
<key>adsbout_adsb_position_source</key>
<param><key>id</key><value>adsbout_adsb_position_source_1</value></param>
<param><key>altitude</key><value>19876.4</value></param>
<param><key>capability</key><value>5</value></param>
<param><key>icao</key><value>0x666777</value></param>
<param><key>intermessagegap</key><value>99564</value></param>
<param><key>latitude</key><value>40.0773267201</value></param>
<param><key>longitude</key><value>116.6003801201</value></param>
<param><key>nicsupplementb</key><value>0</value></param>
<param><key>surface</key><value>False</value></param>
<param><key>surveillancestatus</key><value>0</value></param>
<param><key>time</key><value>0</value></param>
<param><key>typecode</key><value>11</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>limesdr_sink</key>
<param><key>id</key><value>limesdr_sink_0</value></param>
<param><key>allow_tcxo_dac</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>5e6</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>gain</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>pa_path_ch1</key><value>1</value></param>
<param><key>channel_mode</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>dacVal</key><value>125</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>adsbout_adsb_Concentrator_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>adsbout_adsb_ident_source_0</source_block_id><sink_block_id>adsbout_adsb_Concentrator_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>adsbout_adsb_ident_source_1</source_block_id><sink_block_id>adsbout_adsb_Concentrator_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>adsbout_adsb_position_source_0</source_block_id><sink_block_id>adsbout_adsb_Concentrator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>adsbout_adsb_position_source_1</source_block_id><sink_block_id>adsbout_adsb_Concentrator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
