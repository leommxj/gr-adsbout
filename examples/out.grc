options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: adsbout_adsb_Concentrator_0
  id: adsbout_adsb_Concentrator
  parameters:
    gap: '995640'
    ninputs: '5'
  states: {}
- name: adsbout_adsb_ident_source_0
  id: adsbout_adsb_ident_source
  parameters:
    callsign: AB123
    ec: '3'
    icao: '0x666888'
  states: {}
- name: adsbout_adsb_ident_source_1
  id: adsbout_adsb_ident_source
  parameters:
    callsign: CC1234
    ec: '3'
    icao: '0x666777'
  states: {}
- name: adsbout_adsb_position_source_0
  id: adsbout_adsb_position_source
  parameters:
    altitude: '9876.4'
    capability: '5'
    icao: '0x666888'
    intermessagegap: '99564'
    latitude: '40.0773267203'
    longitude: '116.6003801203'
    nicsupplementb: '0'
    surface: 'False'
    surveillancestatus: '0'
    time: '0'
    typecode: '11'
  states: {}
- name: adsbout_adsb_position_source_1
  id: adsbout_adsb_position_source
  parameters:
    altitude: '19876.4'
    capability: '5'
    icao: '0x666777'
    intermessagegap: '99564'
    latitude: '40.0773267201'
    longitude: '116.6003801201'
    nicsupplementb: '0'
    surface: 'False'
    surveillancestatus: '0'
    time: '0'
    typecode: '11'
  states: {}
- name: adsbout_adsb_velocity_source_0
  id: adsbout_adsb_velocity_source
  parameters:
    dif: '0'
    ic: '0'
    icao: '0x666888'
    n2s: '-1000'
    nac: '0'
    subtype: '1'
    vr: '-832'
    vrsrc: '0'
    w2e: '1000'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: gain
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: freq
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}

connections:
- [adsbout_adsb_Concentrator_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [adsbout_adsb_ident_source_0, '0', adsbout_adsb_Concentrator_0, '2']
- [adsbout_adsb_ident_source_1, '0', adsbout_adsb_Concentrator_0, '3']
- [adsbout_adsb_position_source_0, '0', adsbout_adsb_Concentrator_0, '0']
- [adsbout_adsb_position_source_1, '0', adsbout_adsb_Concentrator_0, '1']
- [adsbout_adsb_velocity_source_0, '0', adsbout_adsb_Concentrator_0, '4']
- [blocks_interleaved_char_to_complex_0, '0', limesdr_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
